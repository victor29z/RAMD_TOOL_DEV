# Keil uVision project IDMIB.uvprojx, settings and files
target IDMIB (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: IDMIB +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp/Inc;../Driver/inc;../AX58100/driver;..\Beckhoff_SSC\AppliedSrc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c fsmc.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP/RAMD
    ../Bsp/Src/: BSP_24AA16.c BSP_ADC.c BSP_CAN.c BSP_CPU_ID.c BSP_DO_PWR_CTRL.c BSP_Encrypt.c BSP_Global.c BSP_INA237.c BSP_LED.c BSP_Output.c BSP_SPST.c BSP_STM32_Flash.c BSP_STO.c BSP_Timer.c BSP_UART.c BSP_AX58100.c BSP_ICM20600.c
  group DRIVER/RAMD
    ../Driver/src/: App_Global.c Clock.c Delay.c EEPROM_RW.c Flash_RW.c FT_Sensor.c IMU.c PID_CTRL.c Protocol.c Robot_Drive.c State_Observer.c Test.c Tic_Toc.c Tool_CONN_AI.c Tool_CONN_DIO.c Tool_CONN_RS485.c
  group Bechoff_SSC
    ../Beckhoff_SSC/AppliedSrc/: coeappl.c ecatappl.c ecatcoe.c ecatslv.c mailbox.c objdef.c samplehw.c sdoserv.c ToolAppl.c
  group AX58100_Driver
    ../AX58100/driver/: ax_cfg.h ax_esc_regs.h ax_intf.c ax_intf.h ax_types.h
software components: CMSIS:CORE 5.5.0
